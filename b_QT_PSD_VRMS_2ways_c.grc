options:
  parameters:
    author: Homero Ortega
    category: comdiguis
    generate_options: hb_qt_gui
    id: b_PSD_VRMS_2ways_c
    output_language: python
    title: b_PSD_VRMS_2ways_c
  states: {}

blocks:
- name: Amp
  id: parameter
  parameters:
    label: Amplitud
    value: '1'
  states: {}
- name: E3TRadio_vector_average_hob_0
  id: E3TRadio_vector_average_hob
  parameters:
    N: N
    Nensayos: '1000000000'
  states: {}
- name: Ensayos
  id: parameter
  parameters:
    label: N_ensayos
    value: '1000000'
  states: {}
- name: N
  id: parameter
  parameters:
    label: N_FFT
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./N)
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./(Ensayos*N))
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: mainwidget3
  id: qtgui_tab_widget
  parameters:
    label0: Espectro Dinamico en Volts/Hz
    label1: Especto Dinamico en dB
    label2: PSD (Watts/Hz)
    label3: PSD en dB
    label4: Senal en tiempo
    label5: Constelacion
    num_tabs: '6'
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: Tx
    type: complex
  states: {}
- name: pad_source_2_0
  id: pad_source
  parameters:
    label: Rx
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: mainwidget3@5:0,0
    name: '"Tx"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: mainwidget3@5:0,1
    name: '"Rx"'
    size: '1024'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_audio
    fc: '0'
    fftsize: '1024'
    gui_hint: mainwidget3@1:0,0,1,3
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate_audio
    fc: '0'
    fftsize: '1024'
    gui_hint: mainwidget3@3:0,0,1,3
    label1: Tx
    label2: Rx
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0_0_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'mainwidget3@4: 1,2,1,1'
    name: '"P (dB)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'mainwidget3@4: 1,1,1,1'
    name: '"P"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'mainwidget3@4: 1,0,1,1'
    name: '"VRMS"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: mainwidget3@4:0,0
    label1: Tx.Re
    label2: Tx.Im
    label3: Rx.Re
    label4: Rx.Im
    marker1: '0'
    name: '"Osciloscopio"'
    nconnections: '2'
    size: '32'
    srate: samp_rate_audio
    type: complex
    ymax: Amp
    ymin: '-Amp'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: mainwidget3@2:0,0,1,1
    name: ''
    showports: 'True'
    vlen: N
    x_axis_label: '"Frecuencia"'
    x_start: '-samp_rate_audio/2'
    x_step: (samp_rate_audio-1)/N
    x_units: '"Hz"'
    y_axis_label: '"Amplitud (Watt/Hz)"'
    y_units: '"Watt/Hz"'
    ymax: 1./Ensayos
    ymin: '-1./(4*Ensayos)'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: mainwidget3@0:0,0,1,1
    name: ''
    showports: 'True'
    vlen: N
    x_axis_label: '"Frecuency"'
    x_start: '-samp_rate_audio/2'
    x_step: (samp_rate_audio-1)/N
    x_units: '"Hz"'
    y_axis_label: '"Amplitud (V/Hz)"'
    y_units: '"V"'
    ymax: '0.1'
    ymin: '-0.01'
  states: {}
- name: samp_rate_audio
  id: parameter
  parameters:
    label: Fmuestreo
    value: '22000'
  states: {}

connections:
- [E3TRadio_vector_average_hob_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_rms_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', E3TRadio_vector_average_hob_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_number_sink_0_0_1, '0']
- [blocks_nlog10_ff_0_2, '0', qtgui_number_sink_0_0_0_1, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_rms_xx_0_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_2, '0', blocks_complex_to_mag_1, '0']
- [pad_source_2, '0', blocks_stream_to_vector_0, '0']
- [pad_source_2, '0', qtgui_const_sink_x_0, '0']
- [pad_source_2, '0', qtgui_freq_sink_x_0, '0']
- [pad_source_2, '0', qtgui_freq_sink_x_0_0, '0']
- [pad_source_2, '0', qtgui_time_sink_x_0, '0']
- [pad_source_2_0, '0', qtgui_const_sink_x_0_0, '0']
- [pad_source_2_0, '0', qtgui_freq_sink_x_0_0, '1']
- [pad_source_2_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
