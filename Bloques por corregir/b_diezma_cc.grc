options:
  parameters:
    author: Homero Ortega. Universidad Industrial de Santander. Colombia
    category: comdiguis
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: |-
      Realiza un diezmado del mundo real. Sps es la distancia entre las muestras a diezmar, D es el punto de inicio.
          El codigo esta en diezma_ff.py. 
    generate_options: hb
    id: b_diezma_cc
    output_language: python
    title: b_diezma_cc
  states: {}

blocks:
- name: D
  id: parameter
  parameters:
    label: D
    type: intx
    value: '0'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: D
    N: Sps
  states: {}
- name: E3TRadio_diezma_ff_0_0
  id: E3TRadio_diezma_ff
  parameters:
    M: D
    N: Sps
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    type: intx
    value: '8'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_diezma_ff_0, '0', blocks_float_to_complex_0, '1']
- [E3TRadio_diezma_ff_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '0', E3TRadio_diezma_ff_0_0, '0']
- [blocks_complex_to_float_0, '1', E3TRadio_diezma_ff_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
