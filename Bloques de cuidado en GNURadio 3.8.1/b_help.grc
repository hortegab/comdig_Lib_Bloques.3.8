options:
  parameters:
    author: Homero Ortega Boada
    category: comdiguis
    description: Guardando aqui todos los bloques de programacion embebida
    generate_options: hb_qt_gui
    id: b_help
    output_language: python
    title: b_help
  states: {}

blocks:
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: real
    value: 'True'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: VCO_hob
  id: epy_block
  parameters:
    _source_code: |
      import math
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """genera una senoidad cuyos parametros pueden ser manipulados por las senales entrantes asi: la primera senal manipula la amplitud; la segunda la frecuencia; la tercera la fase"""
          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='VCO_hob',   # will show up in GRC
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[np.float32]
              )
              self.n_m=0 # guarda el ultimo valor de n

          def work(self, input_items, output_items):
              A=input_items[0]
              F=input_items[1]
              P=input_items[2]
              out=output_items[0]
              L=len(A)
              n=np.linspace(self.n_m, self.n_m+L-1,L)
              self.n_m += L
              out[:]=A*np.cos(2*math.pi*F*n+P)
              return len(out)
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: coding
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy\nimport math\n#######################################################\n##        Done by Homero Ortega Boada              ##\n##        comdiguis@saber.uis.edu.co                 ##\n##     Universidad Industrial de Santander           ##\n#######################################################\n#######################################################\n##       Constellation map  identification           ##\n#######################################################                  \n# Constellation points are analyzed to determine the \n# the map used for ordering of the constellation points\ndef sum_modulus(a,b,modulus):\n    # realiza una suma de a y b en modulo modulus\n    return (a+b)%modulus\n\ndef angle_map(constellation_points):\n    # esta funcion entrega todos los angulos positivos entre 0 y 2pi\n    angles=numpy.angle(constellation_points)\n    return sum_modulus(angles, 2*math.pi, 2*math.pi)\n\ndef inverse_map(constellation_points):\n    M=len(constellation_points)\n    angles=angle_map(constellation_points)\n    angles=sum_modulus(angles,-angles[0], 2*math.pi) # giro a agulo cero\n    delta_angle= 2*math.pi/M     # angulo entre puntos\n    cod_inv=numpy.round(angles/delta_angle)\n    cod_inv=cod_inv.astype(numpy.int) #conversion a entero \n    return cod_inv\n\ndef direct_map(constellation_points):\n    M=len(constellation_points)\n    codinv=inverse_map(constellation_points)\n    coddirect=numpy.array([0]*M)\n    for j in range(M):\n        temp=numpy.where(codinv==j)\n        coddirect[j]=temp[0][0]\n    return coddirect\n\n\"\"\" # SECCION DE PRUEBAS DEL CODIGO\nimport gnuradio.digital as digital\nconstelacion=digital.constellation_8psk().points()\nprint(\"constelacion = \", constelacion)\nmapdirect=direct_map(constelacion)\nprint(\"codigo directo = \", mapdirect)\nmapinverse=inverse_map(constelacion)\nprint(\"codigo inverso = \", mapinverse)\n\"\"\"\n\n\n\n\n\n\n"
  states: {}
- name: e_Add
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """Suma dos senales tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_Add_bb',   # will show up in GRC
                  in_sig=[np.int8, np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]+input_items[1]
              return len(output_items[0])
  states: {state: disabled}
- name: e_M_decisor_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """M-ary Decisor. Es un decisor para senales M_PAM. VP es el valor pico de la senal entrante"""
          def __init__(self,M=4, Vp=4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_M_PAM_decisor',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int8]
              )
      	self.M=M
      	self.Vp=Vp

          def work(self, input_items, output_items):
      	mpam_con_ruido=input_items[0]*(self.M+1)/(2*self.Vp)
      	mpam_sin_ruido=np.round(mpam_con_ruido)

              output_items[0][:] = mpam_sin_ruido.astype(np.int8)
              return len(output_items[0])
  states: {state: disabled}
- name: e_Multiply
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """Multiplica dos senales tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_Multiply_bb',   # will show up in GRC
                  in_sig=[np.int8, np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]*input_items[1]
              return len(output_items[0])
  states: {state: disabled}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \n\tin0 para manipular la fase, in1 para manipular la \n\tmagnitud. En el fondo es el equivalente a un generador\n\tde una senal exponencial compleja. Sobre la configuracion:\n\tcada valor de la senal en in0 es interpretada como la fase\n\tdeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n\t    in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n\tin0=input_items[0]\n\tin1=input_items[1]\n\tout0=output_items[0]\n\tout0[:] = in1*np.exp(1.j*in0)\n\treturn len(out0)\n"
  states: {state: disabled}
- name: e_VCO_fase_fc_0_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \n\tin0 para manipular la fase, in1 para manipular la \n\tmagnitud. En el fondo es el equivalente a un generador\n\tde una senal exponencial compleja. Sobre la configuracion:\n\tcada valor de la senal en in0 es interpretada como la fase\n\tdeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n\t    in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n\tin0=input_items[0]\n\tin1=input_items[1]\n\tout0=output_items[0]\n\tout0[:] = in1*np.exp(1.j*in0)\n\treturn len(out0)\n"
  states: {state: disabled}
- name: e_bipol_to_unip
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de bipolar a unipolar una senal tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_bipolar_to_unipolar_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):

              output_items[0][:] = (input_items[0]+1)/2
              return len(output_items[0])
  states: {state: disabled}
- name: e_bipol_to_unip_M
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de bipolar a unipolar una senal tipo char M-aria"""
          def __init__(self, M=2):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_bipolar_to_unipolar_M_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )
      	self.M=M
          def work(self, input_items, output_items):

              output_items[0][:] = (input_items[0]+(self.M-1))/2
              return len(output_items[0])
  states: {state: disabled}
- name: e_c_p
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
          """Autor: Homero Ortega. Permite obtener la fase de una senal compleja. A diferencia de otros bloques de gnuradio, este entrega valores positivos de fase entre 0 y 2pi. M es el numero de posibles fases discretas que trae la senal"""
          def __init__(self,M=4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Complex to Phase',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
      	self.M=M
      	self.p2=2.*np.pi
      	self.p_margen=self.p2/(M*2.)

          def work(self, input_items, output_items):
      	fases=np.angle(input_items[0]) # tiene valores negativos
      	fases=(fases+self.p_margen +self.p2)% self.p2-self.p_margen
              output_items[0][:] = fases
              return len(output_items[0])
  states: {state: disabled}
- name: e_fft_gnu
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class e_vector_fft_mag_ff(gr.sync_block):
          """calcula la fft en magnitud a una senal vectorial de N muestras y emtrega N muestras del espectro. N deber ser potencia de 2"""

          def __init__(self, N=128):  
              gr.sync_block.__init__(
                  self,
                  name='e_vector_mag_fft_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N

          def work(self, input_items, output_items):
              in0 = input_items[0]
          	out0 = output_items[0]
          	out0[:]=abs(np.fft.fftshift(np.fft.fft(in0,self.N),1)) 
              return len(output_items[0])
  states: {state: disabled}
- name: e_fft_gnu_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class e_vector_fft_ff(gr.sync_block):
          """calcula la fft pura a una senal vectorial de N muestras y emtrega N muestras del espectro. N deber ser potencia de 2"""

          def __init__(self, N=128):  
              gr.sync_block.__init__(
                  self,
                  name='e_vector_fft_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N

          def work(self, input_items, output_items):
              in0 = input_items[0]
          	out0 = output_items[0]
          	out0[:]=np.fft.fft(in0,self.N) 
              return len(output_items[0])
  states: {state: disabled}
- name: e_mpam_ph
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """Traduce M_PAM a valores de fase"""
          def __init__(self,M=4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='M_PAM to Phase',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.float32]
              )
      	self.M=M
      	self.p2=2.*np.pi

          def work(self, input_items, output_items):
      	#fases=input_items[0]*self.p2/self.M

              output_items[0][:] = input_items[0]*self.p2/self.M
              return len(output_items[0])
  states: {state: disabled}
- name: e_phase
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """Traduce fases a valores de M_PAM y aplica decisor mediante redondeo"""
          def __init__(self,M=4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='phase to M_PAM',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
      	self.M=M
      	self.p2=2.*np.pi

          def work(self, input_items, output_items):
      	mpam_con_ruido=input_items[0]*self.M/self.p2
      	mpam_sin_ruido=np.round(mpam_con_ruido)

              output_items[0][:] = mpam_sin_ruido
              return len(output_items[0])
  states: {state: disabled}
- name: e_phase_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """Traduce fases a valores de M_PAM y aplica decisor mediante redondeo"""
          def __init__(self,M=4):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='phase to M_PAM',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int8]
              )
      	self.M=M
      	self.p2=2.*np.pi

          def work(self, input_items, output_items):
      	mpam_con_ruido=input_items[0]*self.M/self.p2
      	mpam_sin_ruido=np.round(mpam_con_ruido)

              output_items[0][:] = mpam_sin_ruido.astype(np.int8)
              return len(output_items[0])
  states: {state: disabled}
- name: e_signal
  id: epy_module
  parameters:
    source_code: "################################################################################\n##           Funciones sigulares en Tratamiento de senales y sistemas         ##\n################################################################################\n# Lo siguiente aplica para todas las funciones aqui incluidas:\n# cada funcion busca generar un tipo de forma de pulso rodeada de ceros\n# los resultados se entregan en forma de un vector x\n# Estos son los parametros usados:\n# ntaps: es el tamano del vector y coincide con la duracion de la senal generada\n# nzero: es el numero de ceros que rodean el pulso generado. Si nzero=0 no \n# habran ceros.\nimport numpy as np\n\ndef pulse_rect(ntaps,nzeros):\n# Descripcion: esta funcion permite generar un pulso rectangular discreto\n\tn_val=ntaps-nzeros             # el numero de valores no iguales a cero\n\tx=np.zeros(ntaps)       # crea un vector de tamano ntaps lleno de ceros\n\tntaps_m= int(ntaps/2)                # el punto medio del vector\n\tntaps_i= ntaps_m-int(n_val/2)        # el punto de inicio para los unos\n\tx[ntaps_i:ntaps_i+n_val:1]=np.ones(n_val) # llenado de los unos\n\treturn x\n\ndef pulse_ramp(ntaps,nzeros):\n# Descripcion: esta funcion permite generar un pulso en forma de rampa discreto\n\tn_val=ntaps-nzeros            \n\tx=np.zeros(ntaps)             \n\tntaps_m= int(ntaps/2)         \n\tntaps_i= ntaps_m-int(n_val/2) \n\tx[ntaps_i:ntaps_i+n_ones:1]=np.linspace(0,n_val-1,n_val) \n\treturn x\n\ndef pulse_delta(ntaps):\n# Descripcion: esta funcion permite generar la funcion impulso o funcion\n# delta de Dirac discreta\n\tx=np.zeros(ntaps)                      \n\tntaps_m= int(ntaps/2)                  \n\tx[ntaps_m]=1                           \n\treturn x\n\ndef pulse_doublet(ntaps):\n# Descripcion: esta funcion permite generar una funcion doblete unitario discreta\n\tx=np.zeros(ntaps)                      \n\tntaps_m= int(ntaps/2)                  \n\tx[ntaps_m]=1                           \n\tx[ntaps_m+1]=-1                        \n\treturn x\n\ndef pulse_step(ntaps, nzeros):\n# Descripcion: esta funcion permite generar una funcion escalon de Heaviside\n\tn_val=ntaps-nzeros                     \n\tx=np.zeros(ntaps)                      \n\tx[nzeros:ntaps:1]=np.ones(n_val) \n\treturn x\n\ndef pulse_exp(ntaps,nzeros, C, a):\n# Descripcion: Para generar una funcion exponencial de la forma Ca^n, \n# donde n es tiempo discreto\n\tn_val=ntaps-nzeros                        \n\tx=np.zeros(ntaps)                         \n\tntaps_i = nzeros                    \n\tn=np.linspace(0,n_val-1,n_val)      \n\tx[ntaps_i:ntaps:1]=C*np.power(a,n) \n\treturn x\n\n"
  states: {}
- name: e_unip_to_bipol
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de unipolar a bipolar una senal tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_unipolar to bipolar_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):

              output_items[0][:] = input_items[0]*2-1
              return len(output_items[0])
  states: {state: disabled}
- name: e_unip_to_bipol_M
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de unipolar a bipolar una senal tipo char M-aria. El parametro M es para indicar si la senal es binaria (M=2), cuaternaria M=4, etc"""
          def __init__(self,M=2):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_unipolar to bipolar_M_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )
      	self.M=M

          def work(self, input_items, output_items):

              output_items[0][:] = input_items[0]*2-(self.M-1)
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
          """Coverts phase with some negative values to all positive values"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='positphase',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
      	self.p2=2*np.pi

          def work(self, input_items, output_items):
              output_items[0][:] = (input_items[0] +self.p2) % self.p2
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass mean_meter(gr.sync_block):\n    \"\"\"Descripcion del bloque \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"e_mean_meter_ff\",\n            in_sig=[np.float32],\n            out_sig=[np.float32])\n\n        # variables externas\n\tself.contador = 0\n\tself.acum=0\n    def work(self, input_items, output_items):\n        # traduccion a algo que podemos manejar mejor\n        in0 = input_items[0]\n        out0 = output_items[0]\n        # Logica principal\n\tself.contador += len(in0)\n\tself.acum += np.sum(in0)\n\tout0[:] = self.acum/self.contador\n        return len(output_items[0])\n\n"
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass decimator(gr.decim_block):\n    \"\"\"Elimins paso-1 muestras, de manera que solo quedan vigentes las muestras separadas en paso muestras\"\"\"\n    def __init__(self, paso=2):\n        gr.decim_block.__init__(self,\n            name=\"e_diezmad_ff\",\n            in_sig=[np.float32],\n            out_sig=[np.float32], decim=paso)\n\n        # variables externas\n\tself.paso = paso\n\t\n    def work(self, input_items, output_items):\n        # traduccion a algo que podemos manejar mejor\n        in0 = input_items[0]\n        out0 = output_items[0]\n        # Logica principal\n\tout0[:] = in0[::self.paso]\n        return len(output_items[0])\n\n"
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """Done by Homero Ortega Boada"""

          def __init__(self, samp_rate=200000., Ac=1.):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_VCO_frec_fc',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.complex64]
              )
              self.samp_rate = float(samp_rate)
              self.Ac = Ac
      	self.last_t=0.

          def work(self, input_items, output_items):
      	in0=input_items[0]
      	out0=output_items[0]
              L=len(in0)
      	t=np.arange(L)/self.samp_rate+self.last_t
      	theta=2.*np.pi*in0*t
      	out0[:] = self.Ac*np.exp(1.j*theta)
      	self.last_t += L/self.samp_rate
      	return len(out0)
  states: {state: disabled}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
       
      # Es conveninte hacer que nombre de una clase finalice con una o dos letras especiales:
      # -  nombre_ff: cuando en el bloque sus entradas y salidas son senales reales y de tipo flotante
      # -  nombre_f: el bloque solo tiene una entrada o una salida y es una senal real de tipo flotante
      # -  En vez de "f" pueden usarse: c (senal compleja),  i (entera), b (binaria), etc.
      # -  si el es bloque es vectorial, tambien es importante denotarlo, entonces a las letras
      # anteriores le vamos a anteponer las letras vec
      # -  No es conveniento antepoler letras distintivas al nombre de un bloque ya que eso
      # hace que sea mas dificl de encontrarlo con las ayudas de un IDE com Visual Studio Code
      # -  cuando se trate de un bloque jerarquico, los apuntadores a esos bloques los vamos
      # a  senalar conmenzando el apuntador con p_, por ejemplo p_fuente=my.e_generador_fun_f()
      # Un bloque puede ser de varios tipos y eso se define en la clase como:
      # . gr.sync_block: cuando es de tipo sincrono
      # - gr.top_block: cuando es el flujograma principal
      # - gr.decim_block: cuando hay k muestras en la entrada por cada muestra saliente
      # - gr.interp_block: cuando hay k muestras en la salida por cada muestra entrante
      # - gr.hier_block2: cuando el bloque es como un flujograma
      # . gr.basic_block: otros casos
      # Nota: esta plantilla tambien puede ser consultada en: https://github.com/hortegab/comdig_lib_code.git

      class e_add_cc(gr.sync_block):  
          """Aqui debes explicar como funciona el bloque, los parametros usados. En este caso particular el proposito es que esta clase sirva como ejemplo o plantilla para otras clase. La idea es que cada vez que vayas a crear una clase para un bloque GNU Radio vuelvas aqui ya que no es facil memorizar todos los detalles para crear un bloque GNU Radio. En todo caso, el ejemplo consiste en un bloque para una suma escalada de dos senales complejas. Por lo tanto hay dos senales de entrada y una de salida. Si escala=0.5 lo que se logra es promediar las dos senales"""
       
          # Dentro de la funcion __init__(), deben definirse los parametros de configuracion del bloque.
          # A cada parametro se le da un valor por defecto
          # ejemplo 1, solo hay un parametro de configuracion: def __init__(self, amp=1.0)
          # ejemplo 2, hay dos parametros: def __init__(self, amp=1.0, samp_rate= 32000)
          # - si el bloque es vectorial hay que incluir la variable que marca el tamano del vector
          # para reconocerla siempre usaremos Nvec
          # - Nota: los bloques vectoriales se pueden implementar como embebidos, pero hay
          #          que tener en cuenta que el tamano del vector queda estatico
          #          sujeto al valor configurado internamente en este codigo. Eso quiza sera resuelto
          #          en la siguiente version de gnuradio.
          # por ejemplo def __init__(self, amp=1.0, samp_rate= 32000, Nvec=128)
          # a continuacion esta el caso de un solo parametro que hemos llamado escala
          def __init__(self, escala=0.5):

              # En la siguiente funcion debes recordar que usaras:
              # - sync: cuando tu bloque sea un bloque de tipo sincrono (por cada muestra entrante habra una saliente)
              # - decim: cuando es un bloque decimador (por cada muestra saliente hay un numero entero de muestras entrantes)
              # - interp: cuando es un bloque interpolador (por cada muestra entrante hay un numero entero de muestras salientes)
              # - basic: cuando no hay relacion entre el numero de muestras entrantes y las salientes
              # self: Es necesario para que la funcion adminita el uso de self en su cuerpo para declarar
              # variables que pueden ser usadas por otras funciones.
              # mas en: https://wiki.gnuradio.org/index.php/Guided_Tutorial_GNU_Radio_in_Python#3.3.1._Choosing_a_Block_Type
              gr.sync_block.__init__(
                  self,
       
                  # Lo siguiente es para definir el nombre que tendra nuestro bloque para los usuarios de GRC
                  name='Plantilla__detallada_para_crear_bloques_cc', 

                  # A continuacion se definen los tipos de senales de entrada y salida. Veamos algunos ejemplos:
                  # - [np.complex64]: cuando se tiene una sola senal y es compleja
                  # - [np.float32]: cuando se tiene una sola senal y es de tipo real y flotante
                  # - [np.float32, np.complex64]: cuando hay dos senales: una de tipo real flotante y la otra es compleja
                  # - otros casos: int8 o byte (entero de 8 bits, que en C++ se conoce como char)
                  # - No hemos explorado mas casos, pero no es tan sencillo. Uno supondria que otros casos posibles son:
                  # int16 (en C++ se conoce como short), int32, int64. Los dos primeros funcionan, pero int64 no.
                  # - En el caso de un bloque vectorial aqui hay que indicarlo entre (). Veamos ejemplos:
                  #   Ejemplo 1: el bloque tiene una entraga y unsa salida y ambas son reales y vectoriales
                  #    y el tamano del vectorr es Nvec, entonces se declara asi:
                  #   * in_sig=[(np.float32,Nvec)],
                  #   * out_sig=[(np.float32,Nvec)]
                  # En el siguiente ejemplo hay dos entradas complejas y una salida real. Todas tipo stream 
                  in_sig=[np.complex64,np.complex64], 
                  out_sig=[np.complex64]
              )
       
              # las variables que entran como parametros del bloque deben ser declaradas nuevamente asi:
              self.escala=escala
       
              # abajo se puede escribir lo que se le antoje al programador, por ejemplo:
              # self.coef=1.0: define la variable global coef y le asigna el valor 1.0
              # self significa que es una variable global, que se puede invocar directamente desde otras funciones.
              # En todo caso, para las cosas que se definan aqui hay que tener en cuenta que:
              # -  esto es parte del constructor de la clase, por lo tanto, por cada bloque que se cree con esta clase
              #    estas cosas se invocaran solo una vez
              # -  Se supone que lo que se cree aqui es para ser usado, de manera que deberia ser usado en work()
              # A continuacion vamos a suponer que necesitamos usar constante  coef=1.0
              self.coef = 1.0
       
          # La funcion work() siempre debe estar presente en un bloque. Es alli donde estara la logica del bloque 
          # Es importante que tengas en cuenta lo siguiente:
          # - Para las senales tipo stream se tiene que:
          #    * input_items: es un arreglo de MxN. M es el numero de entradas, N el numero de muestras de la senal
          #    * in0=input_items[0]: es un vector de longitud N, por lo tanto trae N muestras de una senal
          #    * in1=input_items[1]: es un vector de longitud N, por lo tanto trae N muestras de una segunda senal
          #    * M esta definido por la cantidad de entradas que tiene el bloque, es decir, lo declarado arriba en in_sig
          #    * N va cambiando con cada nueva rafaga de muestras, de modo que es un valor desconocido
          #        se puede calcular como N=len(input_items[0])
          # - Si el bloque es de tipo vectorial, tenemos que el bloque input_items es un array MxLxNvec
          #    * M hace referencia a las senales de entrada (representa el fondo de un cubo)
          #    * L Al numero de paquetes recibidos (representa la altura del cubo)
          #    * Nvec al numero de muestras por vector (representa el ancho del cubo)
          #    * A cada entrada le corresponde una matriz LxNvec, por ejemplo para la entrada cero tenmos
          #    * in0=input_items[0] es una matriz LxNvec, es decir una senal que trae L vectores de Nvec muestras
          #    * Por tanto in0[0] es el primer vector de muestras de la senal, in0[1] el segundo, etc.
          # En el caso de output_items, aplica lo mismo dicho para input_items, pero con las senales
          # de salida y lo definido para out_sig
          # el "self" en la declaracion creo que es para que la funcion acepte el uso de self internamente
          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out0 = output_items[0]
              out0[:]=(in0+in1)*self.escala/self.coef
              return len(out0)
    escala: '0.5'
  states: {}
- name: epy_block_0_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Suma por mudulo M"""

          def __init__(self, M=4, sumando=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Sum Mod',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.M = M
      	self.sumando=sumando

          def work(self, input_items, output_items):
              """suma en modulo M"""
              output_items[0][:] = (input_items[0] + self.sumando%self.M)%self.M
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Gray Code Converter. Supongamos que tienes una senal dada en simbolos M_PAM, pero necesitas que esos valores M-PAM se expresen en codigo Gray. Esta seria la solucion"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Gray Code Converter',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              

          def work(self, input_items, output_items):
              """la conversion a gray code"""
              output_items[0][:] = input_items[0] ^ (input_items[0] >> 1)
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_5
  id: epy_block
  parameters:
    Sps: Sps
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Este bloque realiza un diezmado asi: cada Sps muestras solo pasa una"""

          def __init__(self, Sps=8):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='e_diezmador_cc',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64], decim = Sps
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Sps = Sps

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              in0 = input_items[0]
              out = output_items[0]
              out[:] = in0[::self.Sps]
              return len(output_items[0])
  states: {state: disabled}
- name: formas
  id: epy_module
  parameters:
    source_code: "import math\nimport numpy as np\n# Cada funcion siguinete es una forma de pulso para una senal digital\n# Los parametros comunmente usados son:\n# Sps (Samples per simbol): Duracion de un simbolo en tiempo discreto\n# ntaps: es el numero de muestras a generar por simbolo. Esto debido a que,\n# en la practica, un simbolo puede invadir a otros simbolos (ISI), asi que\n# las muestras de un simbolo se pueden expandir mas alla de Sps\n\n# Bipolar non return to zero level signal\ndef B_NRZ_L(Sps):\n    return Sps*[1.,]\n##  Forma sinc \ndef sinc(Sps,ntaps):\n    n=np.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)\n    h=np.sinc(n/Sps)\n    return h\n# forma diente se sierra\ndef saw(Sps):\n    return np.linspace(0,Sps-1,Sps)\t\n# Bipolar non return to zero signal\ndef RZ(Sps):\n    h=Sps*[1.,]\n    Sps_m=int(Sps/2)\n    h[Sps_m+1:Sps:1]=np.zeros(Sps-Sps_m)\n    return h\n\n"
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
      ########################################################
      ##     Bipolar non return to zero level signal        ##
      ########################################################
      def B_NRZ_L(Sps):
          return Sps*[1.,]

      ########################################################
      ##  Forma sinc . Es la misma nyq() que aparece arriba ##
      ########################################################
      def sinc(Sps,ntaps):
          n=np.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=np.sinc(n/Sps)
          return h
      ########################################################
      ##              forma diente se sierra                ##
      ########################################################
      def saw(Sps):
          return np.linspace(0,Sps-1,Sps)	
      ########################################################
      #         Bipolar non return to zero signal           ##
      ########################################################
      def RZ(Sps):
          h=Sps*[1.,]
          Sps_m=int(Sps/2)
          h[Sps_m+1:Sps:1]=np.zeros(Sps-Sps_m)
          return h
  states: {}

connections:
- [analog_noise_source_x_0, '0', epy_block_0_2, '0']
- [analog_sig_source_x_0, '0', epy_block_0_2, '1']
- [epy_block_0_2, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0_2, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
